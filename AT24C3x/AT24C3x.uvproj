# Keil uVision project AT24C3x.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: AT24C3x +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\I2C
  group Source Group 1
    ./: AT24C3x.c AT24C3x.h
  group lib
    ../I2C/Objects/: i2c.LIB
